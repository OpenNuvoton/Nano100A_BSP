# Keil uVision project POWERDOWN_Chk.uvproj, settings and files
target PWRDWN_CHECK (ARM-ADS)
  device: NANO100VD3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: PWRDWN_CHECK +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c include: ..\..\..\Library\Device\Nuvoton\Nano100Series\Include;..\..\..\Library\StdDriver\inc;..\..\..\Library\CMSIS\Include
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_nano100series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
    ../../../Library/Device/Nuvoton/Nano100Series/Source/ARM/: startup_Nano100Series.s
  group Libraries
    ../../../Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group User
    ../: main.c
