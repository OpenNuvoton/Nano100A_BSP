# IAR project SC_ReadSimPhoneBook.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100AN series Nuvoton Nano100AN series (Nano100AN,Nano110AN,Nano120AN,Nano130AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include; ..\..\..\..\Library\StdDriver\inc; ..\..\..\..\Library\SmartcardLib\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SC_ReadSimPhoneBook.bin
  ILINK.IlinkOutputFile: SC_ReadSimPhoneBook.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c sc.c sys.c uart.c
    ../../../../Library/SmartcardLib/: SmartCardLib_IAR.a
  group User
    ../: main.c
