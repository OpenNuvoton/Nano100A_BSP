# IAR project SPI_2BIT_Loopback.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Nano100AN series Nuvoton Nano100AN series (Nano100AN,Nano110AN,Nano120AN,Nano130AN)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\Library\CMSIS\Include; $PROJ_DIR$..\..\..\..\..\Library\Device\Nuvoton\Nano100Series\Include; $PROJ_DIR$..\..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SPI_2BIT_Loopback.bin
  ILINK.IlinkOutputFile: SPI_2BIT_Loopback.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/IAR/: startup_Nano100Series.s
    ../../../../Library/Device/Nuvoton/Nano100Series/Source/: system_Nano100Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c retarget.c spi.c sys.c uart.c
  group User
    ../: main.c
